# Repository daidai100/PCB-stuffs

## KiCad design esp32c3/esp32c3.kicad_pcb

Parts:
D1, D2: LED; LED_0603_1608Metric
J1, J2: Conn_01x07_Pin; Conn_Pin1x7
J3, J4: Conn_01x04_Pin; Conn_Pin_1x4
U1: ESP32-C3-WROOM-02
U2: PCB_USB_Connecter
U3: NJM2845DL1-33-TE1; DPAK228P968X238-4N; PARTREV 2012-10-31
U4, U6: (no value)

Connections:
+3.3V: D1.1 (K), J2.1, J4.3, U1.1 (3V3), U3.3 (VOUT)
GND: D2.1 (K), J2.7, J3.4, J4.4, U1.9 (GND), U1.19 (GND), U2.4 (GND), U3.2 (GND)
unnamed: D1.2 (A), U6.1
unnamed: D2.2 (A), U4.1
unnamed: J1.1, U1.4 (GPIO5/ADC2_CH0)
unnamed: J1.2, U1.5 (GPIO6)
unnamed: J1.3, U1.6 (GPIO7)
unnamed: J1.4, J4.1, U1.8 (GPIO9)
unnamed: J1.5, J4.2, U1.10 (GPIO10)
unnamed: J1.6, U1.11 (GPIO20/U0RXD)
unnamed: J1.7, U1.12 (GPIO21/U0TXD)
unnamed: J2.2, U1.18 (GPIO0/ADC1_CH0/XTAL_32K_P)
unnamed: J2.3, U1.17 (GPIO1/ADC1_CH1/XTAL_32K_N)
unnamed: J2.4, U1.16 (GPIO2/ADC1_CH2)
unnamed: J2.5, U1.15 (GPIO3/ADC1_CH3)
unnamed: J2.6, U1.3 (GPIO4/ADC1_CH4)
unnamed: J3.1, U2.1 (Vcc), U3.1 (VIN)
unnamed: J3.2, U1.14 (GPIO19/USB_D+), U2.2 (D+)
unnamed: J3.3, U1.13 (GPIO18/USB_D-), U2.3 (D-)
unnamed: U1.2 (EN/CHIP_PU), U6.2
unnamed: U1.7 (GPIO8), U4.2

Notes on the sheet:
確認用LED
USB_Aとusb_DIP
DIP右側
I2Cピン用
DIP左側

Board: 2 copper layers, 25.3 x 45.1 mm, 12 parts (0 on the bottom side), 21 nets.

Other parts of the board:
 : LOGO; myQR

File esp32c3/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"D1, D2",0603,2,LED,
"J1, J2",PinHeader_1x07_P2.54mm_Vertical,2,Conn_01x07_Pin,
"J3, J4",Conn_Pin_1x4,2,Conn_01x04_Pin,
U1,ESP32-C3-WROOM-02,1,ESP32-C3-WROOM-02,
U2,PCB_USB_Connecter,1,~,
U3,DPAK228P968X238-4N,1,NJM2845DL1-33-TE1,
"U4, U6",1608Metric,2,~,

## KiCad design esp32c3_test/esp32c3_test.kicad_pcb

Board: 2 copper layers, 21.6 x 47.0 mm, 4 parts (0 on the bottom side), 18 nets.

Parts:
 : LOGO; myQR
J1, J2: Conn_01x09_Pin; Conn_Pin_1x9
U1: ESP32-C3-WROOM-02

Connections:
+3.3V: J2.1, U1.1 (3V3)
GND: J2.9, U1.9 (GND), U1.19 (GND)
unnamed: J1.1, U1.18 (GPIO0/ADC1_CH0/XTAL_32K_P)
unnamed: J1.2, U1.17 (GPIO1/ADC1_CH1/XTAL_32K_N)
unnamed: J1.3, U1.16 (GPIO2/ADC1_CH2)
unnamed: J1.4, U1.15 (GPIO3/ADC1_CH3)
unnamed: J1.5, U1.14 (GPIO19/USB_D+)
unnamed: J1.6, U1.13 (GPIO18/USB_D-)
unnamed: J1.7, U1.12 (GPIO21/U0TXD)
unnamed: J1.8, U1.11 (GPIO20/U0RXD)
unnamed: J1.9, U1.10 (GPIO10)
unnamed: J2.2, U1.2 (EN/CHIP_PU)
unnamed: J2.3, U1.3 (GPIO4/ADC1_CH4)
unnamed: J2.4, U1.4 (GPIO5/ADC2_CH0)
unnamed: J2.5, U1.5 (GPIO6)
unnamed: J2.6, U1.6 (GPIO7)
unnamed: J2.7, U1.7 (GPIO8)
unnamed: J2.8, U1.8 (GPIO9)

## Commit log

2023-07-26 added files
2023-11-18 d4版の追加
2023-12-12 c3d4を最新に更新

Notices in the files:
esp32c3/esp32c3.kicad_pcb:
©22-Daidai
